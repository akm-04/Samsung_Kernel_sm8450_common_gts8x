## drivers/staging/qcacld-3.0/configs/qca6490_defconfig
```kconfig
DEVNAME := wlan
CONFIG_CNSS_QCA6490 := y
CONFIG_ARCH_WAIPIO := y
include $(WLAN_ROOT)/configs/default_defconfig
```
